Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-05-13T16:23:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 13 16:23:07 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{0750418A-04D9-4989-B2D4-83D080CE15AB}\ifc * Database version: 5507 * Database creation date: Mon May 13 16:23:07 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 13 16:23:07 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 13 16:23:07 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5711F Washbasin faucet, 5711F(2018):5711F Washbasin faucet:366004
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5711F(2018); ConvergoRefNr: 0087-1905-0011-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 10/04/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150087851; EN Standard: EN 817; LVI Number: 6110277; Noise Class: I (ISO 3822); NRF Number: 4200255
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5711F; Catalog Drawing URL: http://static.oras.com/catdrw/5711F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/5711F; FDV Document URL: http://www.oras.com/datasheet/5711F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5711F; Group: Washbasin faucets; Long Marketing: Oras Care washbasin faucet with fixed spout. Ergonomic lever offers good usability to all users and situations. In-built limitation options for water temperature and maximum flow-rate. Flexible connection pipes G3/8".; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 5711F Washbasin faucet; Name_en: 5711F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 380 x 180 x 74; Product Code: 5711F; Product Datasheet: http://www.oras.com/datasheet/5711F/en; Product Family: Oras Care; Product Image URL: http://static.oras.com/image/5711F; Product URL: http://static.oras.com/5711F; Type Name: 5711F Washbasin faucet; Usage Group: Offices, personnel sanitary facilities;Kindergartens;Schools;Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Aerator: Pressure controlled aerator;CASCADE®; CWFU: 0; Flow Rate At 300kPa: 0.00635664 m3/s; Installation and Maintenance: http://static.oras.com/manual/5711F; Installation Type: Deck mounted; Lever Handle: Long lever;Easy to use lever; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 95000 Pa; Spare Parts: http://static.oras.com/sp/5711F; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Health care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5711F(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5711F; Name: 5711F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x152x178 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Comfort Sales Arguments: Quick and easy to clean.
Pset_ManufacturerTypeInformation - ModelReference: 5711F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5711F Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.044415 m2; Volume: 0.00134079 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5711F(2018): 5711F Washbasin faucet; Family and Type: 5711F(2018): 5711F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5711F(2018): 5711F Washbasin faucet; Type Id: 5711F(2018): 5711F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
